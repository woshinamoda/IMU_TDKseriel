# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MEMS_20648,MEMS_WEARABLE_DEVICE,MEMS_SECONDARY_DEVICE,MEMS_AUGMENTED_SENSORS,
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\flash;..\SYSTEM\wdg;..\HARDWARE;..\ICM_20948\Mems;..\ICM_20948\Mems\common;..\ICM_20948\Mems\dmp3;..\ICM_20948\Mems\dmp3a;..\ICM_20948\Mems\driver;..\ICM_20948\Mems\invn;..\ICM_20948\Mems\invn\common;..\ICM_20948\Mems\invn\common\msvc;..\ICM_20948
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/: spi.c gpio.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_cec.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_fsmc.c stm32f10x_spi.c
  group icm_20948
    ../ICM_20948/: icm20948.c
  group icm_common
    ../ICM_20948/Mems/common/: inv_mems_drv_hook.c
  group icm_dmp3
    ../ICM_20948/Mems/dmp3/: dmp3Default_20608D.c inv_mems_interface_mapping.c
  group icm_dmp3a
    ../ICM_20948/Mems/dmp3a/: dmp3Default_20648.c
  group icm_driver
    ../ICM_20948/Mems/driver/: inv_mems_augmented_sensors.c inv_mems_base_control.c inv_mems_base_control_20609.c inv_mems_base_driver.c inv_mems_base_driver_20609.c inv_mems_data_converter.c inv_mems_load_firmware.c inv_mems_mpu_fifo_control.c inv_mems_mpu_selftest.c inv_mems_mpu_selftest_20609.c inv_mems_secondary_transport.c inv_mems_slave_compass.c inv_mems_slave_pressure.c inv_mems_transport.c
  group icm_invn
    ../ICM_20948/Mems/invn/common/: ml_math_func.c mlmath.c
